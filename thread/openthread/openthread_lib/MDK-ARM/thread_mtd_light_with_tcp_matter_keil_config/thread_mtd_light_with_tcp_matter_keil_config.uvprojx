# Keil uVision project thread_mtd_light_with_tcp_matter_keil_config.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0-RC1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: stm32wba_mtd_light_with_tcp_matter_lib (library)
  AfterMake: ..\POST_BUILD_COPY.bat #L @L
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: _AEABI_PORTABILITY_LEVEL=1,WBx_OTLIB_BUILD_IAR_KEIL,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<stm32wba-mbedtls-config.h>,MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa-crypto-config.h>,OPENTHREAD_CONFIG_FILE=<stm32wba-openthread-light-with-tcp-config.h>,OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wba-openthread-light-with-tcp-config.h>,OPENTHREAD_MTD,OT_LIGHT,memmove=ble_memmov,memcpy=ble_memcpy
  c misc: -fshort-enums -mno-unaligned-access
  c include: ..\..\..\stack\src\diag;..\..\..\stack\src;..\..\..\stack\src\core;..\..\..\stack\include;..\..\..\stack\include\openthread;..\..\..\stack\include\openthread\platform;..\..\..\stack\examples\platforms;..\..\..\stack\examples\platforms\utils;..\..\..\config;..\..\..\stack\wbx_include;..\..\..\stack\wbx_include\sys;..\..\..\platform;..\..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Third_Party\mbedtls\include;..\..\..\..\..\mbedtls\config;..\..\..\..\..\mbedtls\inc;..\..\..\..\..\..\..\Third_Party\mbedtls\include\mbedtls;..\..\..\..\..\..\mbedtls_alt\interfaces\patterns;..\..\..\stack\src\include;..\..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include;..\..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: -library_interface=aeabi_clib
  group examples_apps_cli
    ../../../stack/examples/apps/cli/: cli_uart.cpp
  group examples_platforms_utils
    ../../../stack/examples/platforms/utils/: link_metrics_renamed.cpp mac_frame_renamed.cpp debug_uart.c
  group src_cli
    ../../../stack/src/cli/: cli.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_history.cpp cli_joiner.cpp cli_network_data.cpp cli_srp_client.cpp cli_srp_server.cpp cli_tcp.cpp cli_udp.cpp cli_bbr.cpp cli_dns.cpp cli_mac_filter.cpp cli_link_metrics.cpp cli_mdns.cpp cli_ping.cpp cli_tcat.cpp cli_utils.cpp
  group src_core_api
    ../../../stack/src/core/api/: backbone_router_api.cpp backbone_router_ftd_api.cpp border_agent_api.cpp border_router_api.cpp border_routing_api.cpp channel_manager_api.cpp channel_monitor_api.cpp child_supervision_api.cpp coap_api.cpp coap_secure_api.cpp commissioner_api.cpp crypto_api.cpp dataset_api.cpp dataset_ftd_api.cpp dataset_updater_api.cpp diags_api.cpp dns_api.cpp dns_server_api.cpp error_api.cpp heap_api.cpp history_tracker_api.cpp icmp6_api.cpp instance_api.cpp ip6_api.cpp jam_detection_api.cpp joiner_api.cpp link_api.cpp link_metrics_api.cpp link_raw_api.cpp logging_api.cpp message_api.cpp multi_radio_api.cpp nat64_api.cpp netdata_api.cpp netdata_publisher_api.cpp netdiag_api.cpp network_time_api.cpp ping_sender_api.cpp random_crypto_api.cpp random_noncrypto_api.cpp server_api.cpp sntp_api.cpp srp_client_api.cpp srp_client_buffers_api.cpp srp_server_api.cpp tasklet_api.cpp tcp_api.cpp tcp_ext_api.cpp thread_api.cpp thread_ftd_api.cpp trel_api.cpp udp_api.cpp mesh_diag_api.cpp ble_secure_api.cpp mdns_api.cpp verhoeff_checksum_api.cpp
  group src_core_backbone_router
    ../../../stack/src/core/backbone_router/: backbone_tmf.cpp bbr_leader.cpp bbr_local.cpp bbr_manager.cpp multicast_listeners_table.cpp ndproxy_table.cpp
  group src_core_border_router
    ../../../stack/src/core/border_router/: infra_if.cpp routing_manager.cpp
  group src_core_coap
    ../../../stack/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
  group src_core_common
    ../../../stack/src/core/common/: appender.cpp binary_search.cpp data.cpp error.cpp frame_builder.cpp frame_data.cpp heap_data.cpp heap_renamed.cpp heap_string.cpp log.cpp message.cpp notifier.cpp random.cpp settings.cpp string.cpp tasklet.cpp time_ticker.cpp timer.cpp tlvs.cpp trickle_timer.cpp uptime.cpp preference.cpp crc.cpp offset_range.cpp bit_utils.cpp
  group src_core_crypto
    ../../../stack/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp hkdf_sha256.cpp hmac_sha256.cpp mbedtls.cpp sha256.cpp storage.cpp crypto_platform_mbedtls.cpp crypto_platform_psa.cpp
  group src_core_diags
    ../../../stack/src/core/diags/: factory_diags.cpp
  group src_core_mac
    ../../../stack/src/core/mac/: channel_mask.cpp data_poll_handler.cpp data_poll_sender.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp mac_links.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp sub_mac_csl_receiver.cpp mac_header_ie.cpp scan_result.cpp
  group src_core_meshcop
    ../../../stack/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_manager.cpp dataset_manager_ftd.cpp dataset_updater.cpp energy_scan_client.cpp extended_panid.cpp joiner.cpp joiner_router.cpp meshcop.cpp meshcop_leader.cpp meshcop_tlvs.cpp network_name.cpp panid_query_client.cpp timestamp.cpp secure_transport.cpp tcat_agent.cpp network_identity.cpp seeker.cpp steering_data.cpp
  group src_core_net
    ../../../stack/src/core/net/: checksum.cpp dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp dns_dso.cpp dns_types.cpp dnssd_server.cpp icmp6.cpp ip4_types.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp nat64_translator.cpp nd_agent.cpp nd6.cpp netif.cpp sntp_client.cpp socket.cpp srp_client.cpp srp_server.cpp tcp6.cpp tcp6_ext.cpp udp6.cpp dnssd.cpp mdns.cpp srp_advertising_proxy.cpp dhcp6_types.cpp slaac_address.cpp
  group src_core_radio
    ../../../stack/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp trel_interface.cpp trel_link.cpp trel_packet.cpp ble_secure.cpp
  group src_core_thread
    ../../../stack/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp anycast_locator.cpp child_table.cpp csl_tx_scheduler.cpp discover_scanner.cpp dua_manager.cpp energy_scan_server.cpp indirect_sender.cpp key_manager.cpp link_metrics.cpp link_metrics_types.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_tlvs.cpp mle_types.cpp mlr_manager.cpp neighbor_table.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_data_notifier.cpp network_data_publisher.cpp network_data_service.cpp network_data_tlvs.cpp network_data_types.cpp network_diagnostic.cpp panid_query_server.cpp radio_selector.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp tmf.cpp uri_paths.cpp child_supervision.cpp child.cpp neighbor.cpp router.cpp network_diagnostic_tlvs.cpp thread_link_info.cpp message_framer.cpp vendor_info.cpp
  group src_core_utils
    ../../../stack/src/core/utils/: channel_manager.cpp channel_monitor.cpp flash.cpp heap.cpp history_tracker.cpp jam_detector.cpp otns.cpp parse_cmdline.cpp ping_sender.cpp srp_client_buffers.cpp mesh_diag.cpp link_metrics_manager.cpp verhoeff_checksum.cpp
  group ncp
    ../../../stack/src/ncp/: changed_props_set.cpp example_vendor_hook.cpp ncp_base.cpp ncp_base_dispatcher.cpp ncp_base_ftd.cpp ncp_base_radio.cpp ncp_hdlc.cpp ncp_spi.cpp
  group third_party_mbedtls
    ../../../../../../../Third_Party/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa_renamed.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error_renamed.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c sha1.c sha256_renamed.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cookie.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c aesce.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c ecdsa.c ecp_curves_new.c error.c lmots.c lms.c pk_ecc.c pkcs7.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ffdh.c psa_crypto_pake.c psa_util.c rsa_alt_helpers.c sha3.c sha256.c ssl_client.c ssl_debug_helpers_generated.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_server.c x509write.c
  group third_party_tcplp_bsdtcp_cc
    ../../../stack/third_party/tcplp/bsdtcp/cc/: cc_newreno.c
  group third_party_tcplp_bsdtcp
    ../../../stack/third_party/tcplp/bsdtcp/: tcp_input.c tcp_output.c tcp_reass.c tcp_sack.c tcp_subr.c tcp_timer.c tcp_timewait.c tcp_usrreq.c tcp_fastopen.c
  group third_party_tcplp_lib
    ../../../stack/third_party/tcplp/lib/: bitmap.c cbuf.c lbuf.c
  group src_core_instance
    ../../../stack/src/core/instance/: instance.cpp
