# Keil uVision project thread_mtd_light_with_tcp_matter_mbedtls_config.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0-RC1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: stm32wba_mbedtls_mtd_light_with_tcp_lib (library)
  AfterMake: ..\POST_BUILD_COPY.bat #L @L
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: _AEABI_PORTABILITY_LEVEL=1,WBx_OTLIB_BUILD_IAR_KEIL,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<mbedtls-config.h>,MBEDTLS_USER_CONFIG_FILE=<stm32wba-mbedtls-config.h>,OPENTHREAD_CONFIG_FILE=<stm32wba-openthread-light-with-tcp-config.h>,OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wba-openthread-light-with-tcp-config.h>,OPENTHREAD_MTD,OT_LIGHT,STM32WBA55xx,memmove=ble_memmov,memcpy=ble_memcpy
  c misc: -fshort-enums -mno-unaligned-access
  c include: ..\..\..\stack\src;..\..\..\stack\include;..\..\..\stack\include\openthread;..\..\..\stack\include\openthread\platform;..\..\..\..\..\..\..\Third_Party\mbedtls\include;..\..\..\..\..\..\..\Third_Party\mbedtls\configs;..\..\..\stack\examples\platforms;..\..\..\stack\examples\platforms\utils;..\..\..\stack\third_party\mbedtls;..\..\..\stack\wbx_include;..\..\..\stack\wbx_include\sys;..\..\..\..\..\..\..\Third_Party\mbedtls\include;..\..\..\stack\src\core;..\..\..\config;..\..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc;..\..\..\..\..\..\mbedtls_alt\interfaces\patterns;..\..\..\..\..\..\..\Third_Party\mbedtls\library;..\..\..\stack\src\include;..\..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: -library_interface=aeabi_clib
  group third_party_mbedtls
    ../../../../../../../Third_Party/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cookie.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c aesce.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c ecp_curves_new.c lmots.c lms.c pk_ecc.c pkcs7.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ffdh.c psa_crypto_pake.c psa_util.c rsa_alt_helpers.c sha3.c ssl_client.c ssl_debug_helpers_generated.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_server.c x509write.c
  group mbedtls_alt
    ../../../../../../mbedtls_alt/interfaces/patterns/: aes_alt.c ecdh_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c entropy_hardware_alt.c gcm_alt.c rsa_alt.c sha256_alt.c
  group src_core_crypto
    ../../../stack/src/core/crypto/: crypto_platform_mbedtls.cpp crypto_platform_psa.cpp
