# Keil uVision project thread_rcp_keil_config.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0-RC1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: stm32wba_ot_rcp_lib (library)
  AfterMake: ..\POST_BUILD_COPY.bat #L @L
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: _AEABI_PORTABILITY_LEVEL=1,WBx_OTLIB_BUILD_IAR_KEIL,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<stm32wba-mbedtls-config.h>,MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa-crypto-config.h>,OPENTHREAD_CONFIG_FILE=<stm32wba-openthread-rcp-config.h>,OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wba-openthread-rcp-config.h>,OPENTHREAD_RADIO,OPENTHREAD_CONFIG_NCP_HDLC_ENABLE=1,_AEABI_PORTABILITY_LEVEL=1,SPINEL_PLATFORM_DOESNT_IMPLEMENT_ERRNO_VAR,PKA_HW_ACCELERATION,memmove=ble_memmov,memcpy=ble_memcpy
  c misc: -fshort-enums -mno-unaligned-access
  c include: ..\..\..\stack\src\diag;..\..\..\stack\src;..\..\..\stack\src\core;..\..\..\stack\include;..\..\..\stack\include\openthread;..\..\..\stack\include\openthread\platform;..\..\..\stack\examples\platforms;..\..\..\stack\examples\platforms\utils;..\..\..\config;..\..\..\stack\wbx_include;..\..\..\stack\wbx_include\sys;..\..\..\platform;..\..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Third_Party\mbedtls\include;..\..\..\..\..\mbedtls\config;..\..\..\..\..\mbedtls\inc;..\..\..\..\..\..\..\Third_Party\mbedtls\include\mbedtls;..\..\..\..\..\..\mbedtls_alt\interfaces\patterns;..\..\..\stack\src\include;..\..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include;..\..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: -library_interface=aeabi_clib
  group examples_platforms_utils
    ../../../stack/examples/platforms/utils/: link_metrics.cpp
  group src_core_api
    ../../../stack/src/core/api/: error_api.cpp instance_api.cpp link_raw_api.cpp logging_api.cpp random_noncrypto_api.cpp tasklet_api.cpp
  group src_core_common
    ../../../stack/src/core/common/: binary_search.cpp error.cpp frame_builder.cpp frame_data.cpp log.cpp random.cpp string.cpp tasklet.cpp timer.cpp
  group src_core_mac
    ../../../stack/src/core/mac/: link_raw.cpp mac_frame.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp mac_header_ie.cpp
  group src_core_radio
    ../../../stack/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp
  group src_core_thread
    ../../../stack/src/core/thread/: link_metrics_types.cpp link_quality.cpp mle_tlvs.cpp
  group src_core_utils
    ../../../stack/src/core/utils/: parse_cmdline.cpp
  group ncp
    ../../../stack/src/ncp/: changed_props_set.cpp example_vendor_hook.cpp ncp_base.cpp ncp_base_dispatcher.cpp ncp_base_radio.cpp ncp_hdlc.cpp ncp_spi.cpp multipan_platform.cpp
  group examples_app_ncp
    ../../../stack/examples/apps/ncp/: ncp.c
  group lib_hdlc
    ../../../stack/src/lib/hdlc/: hdlc.cpp
  group lib_platform
    ../../../stack/src/lib/platform/: exit_code.c
  group lib_spinel
    ../../../stack/src/lib/spinel/: spinel.c spinel_buffer.cpp spinel_decoder.cpp spinel_encoder.cpp
  group src_core_instance
    ../../../stack/src/core/instance/: instance.cpp
